<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\NC210-200&#x5904;&#x7406;&#x677F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


